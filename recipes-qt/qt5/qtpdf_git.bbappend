COMPATIBLE_MACHINE:loongarch64 = "(.*)"